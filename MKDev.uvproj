# Keil uVision project MKDev.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: MKDev +hex
  c flags: Optimize=6 SizeSpeed=1
  group Source Group
    ./: main.c README.TXT
    ./Public/: DEBUG.C
